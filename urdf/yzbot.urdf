Commit message: bug when publish urdf

File: urdf/yzbot.urdf (robot description, URDF)
Before this commit: robot amr_tvc, 4 links, 3 joints
Links:
- added link gps
Joints:
- added joint gps_joint: type fixed, parent velodyne, child gps, origin xyz=-0.075 -0.1 -0.05 rpy=0.0 0.0 0.0
